# Keil uVision project cy001.uvprojx, settings and files
target Debug (6140000::V6.14::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: cy001 +hex
  AfterMake: fromelf --bin #L --output bin\@L.bin
  AfterMake: cmd /c copy /y $L@L.hex bin\@L.hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F103xE, USE_HAL_DRIVER, USE_FULL_LL_DRIVER, HSE_VALUE=8000000, CONFIG_OPTIONS_FILE=<config/options.h>, CONFIG_HEAP_PORT_FILE=<config/heap_port.h>
  c include: ..\..\..\arch\stm32f10x\inc;..\bsp\inc;..\cpu\inc;..\;..\..\..\common\inc;..\..\..\driver\include;..\..\..\inc;..\..\..\lib\st\stm32f10x\peripherals\inc;..\..\..\lib\st\stm32f10x\peripherals\inc\Legacy;..\..\..\utils\include;..\..\..\components\heap\inc;..\resource\inc;..\src\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\config\arm\cy001.sct
  group cpu
    ../../../arch/stm32f10x/: system_stm32f1xx.c
    ../cpu/: cpu.c stm32f1xx_it.c
    ../cpu/arm/: startup_stm32f103xe.s
  group bsp
    ../bsp/: bsp_com.c bsp_embed_flash.c bsp_w25qxx.c bsp_wdt.c
  group src
    ../src/: fputc.c main.c plat.c
  group resource
    ../resource/: resource_pool.c
  group lib
    ../../../lib/st/stm32f10x/peripherals/src/: stm32f1xx_ll_gpio.c stm32f1xx_ll_spi.c stm32f1xx_ll_rcc.c stm32f1xx_ll_usart.c stm32f1xx_ll_utils.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_cortex.c
  group common
    ../../../common/: resource_manager.c
  group components/heap
    ../../../components/heap/: heap.c
  group driver
    ../../../driver/: device.c driver.c flash.c fm25qxx.c gpio.c serial.c wdt.c
  group utils
    ../../../utils/: checksum.c md5.c utils.c
